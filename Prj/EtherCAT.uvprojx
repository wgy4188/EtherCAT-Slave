# Keil uVision project EtherCAT.uvprojx, settings and files
target flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT2000 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER, STM32F446xx,
  c include: ..\App;..\Cmsis;..\Lib\Inc;..\Lib\Inc\Legacy;..\Cat;..\Drv;..\uCos_ii;..\uCos_ii\uCCPU;..\uCos_ii\uCPort;..\uCos_ii\uCSource;..\uCos_ii\uCLib;..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../App/: main.c bsp.c stm32f4xx_it.c rtt_cmd.c
  group bsp
    ../Drv/: dio.c pwm.c exti.c qspi.c time.c uart.c lan9252.c ad_da.c
  group cat
    ../Cat/: coeappl.c ecatappl.c ecatcoe.c ecateoe.c ecatfoe.c ecatslv.c emcy.c eoeappl.c foeappl.c mailbox.c objdef.c RT2000.c sdoserv.c
  group fwlib
    ../Lib/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c
  group cmsis
    ../Cmsis/: startup_stm32f446xx.s system_stm32f4xx.c
  group uCCPU
    ../uCos_ii/uCCPU/: cpu_a.asm cpu_c.c
  group uCPort
    ../uCos_ii/uCPort/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCSource
    ../uCos_ii/uCSource/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
